# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10; X8_FLY
  ICCARM.CCIncludePath2: ..\Code\inc; ..\..\..\Src\Board\Inc; ..\..\..\Src\Chip\inc; ..\..\..\Src\Chip\inc\IAR; ..\..\..\Src\Chip\inc\kinetis; ..\..\..\Src\Com\inc; ..\..\..\Src\Lib\CMSIS\Inc; ..\..\..\Src\Lib\FatFs; ..\..\..\Src\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\..\Src\Com\config files\vcan_ROM_K60N512.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Src\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: README.md
  group Board/inc
    ../../../Src/Board/inc/: VCAN_ASCII.h VCAN_camera.h VCAN_key.h VCAN_LCD.h VCAN_LCD_ILI9341.h VCAN_LED.H VCAN_MMA7455.h VCAN_NRF24L0.h VCAN_OV7725_Eagle.h VCAN_OV7725_REG.h VCAN_RTC_count.h VCAN_SCCB.h
  group Board/src
    ../../../Src/Board/src/: VCAN_ASCII.c VCAN_camera.c VCAN_key.c VCAN_LCD.c VCAN_LCD_ILI9341.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_OV7725_Eagle.c VCAN_RTC_count.C VCAN_SCCB.c
  group Chip/inc
    ../../../Src/Chip/inc/: common.h misc.h MK60_adc.h MK60_can.h MK60_dac.h MK60_dma.h MK60_DWT.h MK60_flash.h MK60_flexbus.h MK60_FTM.h MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.h MK60_lptmr.h MK60_mcg.h MK60_pit.h MK60_port.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_SysTick.h MK60_uart.h MK60_wdog.h vectors.h
    ../../../Src/Chip/inc/IAR/: iar.h system_MK60DZ10.h
  group Chip/src
    ../../../Src/Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../../Src/Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group Code/inc
    ../Code/inc/: control.h main.h pti.h
    ../Code/src/: swave.h
  group Code/src
    ../Code/src/: control.c main.c pti.c swave.c
  group Com/inc
    ../../../Src/Com/inc/: include.h MK60_conf.h MK60_it.h PORT_cfg.h
  group Com/src
    ../../../Src/Com/src/: MK60_conf.c MK60_it.c
  group Lib/CMSIS/inc
    ../../../Src/Lib/CMSIS/Inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group Lib/FatFs/inc
    ../../../Src/Lib/FatFs/: diskio.h ff.h ffconf.h integer.h
  group Lib/FatFs/src
    ../../../Src/Lib/FatFs/: diskio.c ff.c
  group Lib/USB/inc
    ../../../Src/Lib/USB/: FslTypes.h usb.h USB_CDC.h USB_Desc.h
  group Lib/USB/src
    ../../../Src/Lib/USB/: USB.c USB_CDC.c
